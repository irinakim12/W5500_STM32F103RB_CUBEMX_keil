# Keil uVision project W5x00-HTTPServer.uvprojx, settings and files
target W5x00-HTTPServer (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: W5x00-HTTPServer +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB,KEIL
  c include: ..\Inc;       ..\Src;       ..\Drivers\STM32F1xx_HAL_Driver\Inc;       ..\Drivers\STM32F1xx_HAL_Driver\Inc\Legacy;       ..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;       ..\Drivers\CMSIS\Include;       ..\..\..\ioLibrary_Driver\Application\loopback;       ..\..\..\ioLibrary_Driver\Ethernet\W5500;       ..\..\..\ioLibrary_Driver\Ethernet;       ..\..\..\ioLibrary_Driver\Internet\httpServer
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Ethernet
    ../../../ioLibrary_Driver/Ethernet/: socket.c wizchip_conf.c
    ../../../ioLibrary_Driver/Ethernet/W5500/: w5500.c
  group Internet
    ../../../ioLibrary_Driver/Internet/httpServer/: httpParser.c httpServer.c httpUtil.c
  group Application
    ../../../ioLibrary_Driver/Application/loopback/: loopback.c
  group Application/User
    ../Src/: wizchip_init.c main.c stm32f1xx_it.c stm32f1xx_hal_msp.c userHandler.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
software components: CMSIS:CORE 4.3.0
